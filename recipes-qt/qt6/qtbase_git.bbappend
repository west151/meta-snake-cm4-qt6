PACKAGECONFIG_append = " accessibility fontconfig sql-sqlite kms gbm linuxfb"
PACKAGECONFIG_remove = "examples tests"
